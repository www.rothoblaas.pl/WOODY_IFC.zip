Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 4320a551-ba6e-4b23-8a17-f62fe52e3f0b, NumberOfSaves: 34], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_Plate_Woody_65.ifc
Time: 2025-07-14T16:44:20
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcMember: Collegamenti strutturali : ROTHOB_Rothoblaas_Plate_Woody_65 : WOODY65_65x65x28mm
In: 0_Rothoblaas
Type - PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_MultilayerTimber
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Plate_Woody_65; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: www.rothoblaas.com/products/fastening/brackets-and-plates/concealed-connections/woody; Revision: 000; UniClass2015Code: Pr_20_85_08_87; UniClass2015Title: Structural wood composites; UniClass2015Version: Products v1.38; Version: 002
Type - Vincoli - Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_MultilayerTimber
Type - Quote - Height_H: 28 mm; Length_L: 65 mm; Width_B: 65 mm
Type - Dati identità - Nome del tipo: WOODY65_65x65x28mm; Numero OmniClass: 23.13.23.11.19.13; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_85_08_87 - Structural wood composites; CECode: n/a; CETitle: n/a; CodePerformance: n/a; Color: Brown; Constituents: n/a; Description: Timber connector for walls, floors and roofs; DurationUnit: Years; ExpectedLife: 50; Features: n/a; Finish: n/a; Grade: n/a; GTIN: 8054045430003; ICC-ESCode: n/a; ICC-ESTitle: n/a; Manufacturer: info@rothoblaas.com; Material: Multilayer timber; MinWeight: 0.05 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: WOODY65; ModelReference: n/a; Name: Plate; Nome famiglia: ROTHOB_Rothoblaas_Plate_Woody_65; NominalHeight: 28 mm; NominalLength: 65 mm; NominalWidth: 65 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 65x65x28 mm; Size_Imperial: 2 9/16 x 2 9/16 x 1 1/8 in; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Brown
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_MemberCommon - IsExternal: no
Type - Pset_ProductRequirements - Name: Plate; Category: Pr_20_85_08_87 - Structural wood composites
Pset_MemberCommon - Reference: WOODY65_65x65x28mm
Pset_QuantityTakeOff - Reference: WOODY65_65x65x28mm
BaseQuantities - NetVolume: 0.0000849182 m3; NetSurfaceArea: 0.0159337 m2
Vincoli - Host: Piano di riferimento : REF; Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Quota altimetrica da livello: 1219.2 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Volume: 0.0000849182 m3
Altro - Famiglia: ROTHOB_Rothoblaas_Plate_Woody_65; Famiglia e tipo: ROTHOB_Rothoblaas_Plate_Woody_65: WOODY65_65x65x28mm; ID tipo: 419795; Tipo: WOODY65_65x65x28mm
